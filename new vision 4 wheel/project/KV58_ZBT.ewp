# IAR project KV58_ZBT.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MKV58F1M0VLQ24
  ICCARM.CCDiagSuppress: Pa182,Pa082
  ICCARM.CCIncludePath2: ..\src\app; ..\src\CMSIS; ..\src\Control; ..\src\drivers; ..\src\fsl; ..\src\startup; ..\src\utilities; ..\src; ..\src\ugfx; ..\src\ugfx\drivers\gdisp\ILI9341; ..\src\ugfx\src\gdisp; ..\src\ugfx\src; ..\src\Control\menu; ..\src\fatfs; ..\src\Control\menu; ..\src\app\Process
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KV58_ZBT.bin
  ILINK.IlinkOutputFile: KV58_ZBT.out
  ILINK.IlinkIcfFile: ..\project\MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ24
  ICCARM.CCIncludePath2: ..\src\app; ..\src\CMSIS; ..\src\Control; ..\src\drivers; ..\src\fsl; ..\src\startup; ..\src\utilities; ..\src; ..\src\ugfx; ..\src\ugfx\drivers\gdisp\ILI9341; ..\src\ugfx\src\gdisp; ..\src\ugfx\src; ..\src\Control\menu; ..\src\fatfs
  ICCARM.CCOptLevel: 3
  group App
    ../src/app/: define.c define.h event_delay.c event_delay.h include.h isr.c isr.h Loop.c mymath.c mymath.h Port_cfg.h Sys_init.c Sys_init.h
  group App/Process
    ../src/app/Process/: breakage_process.c breakage_process.h Cross.c Cross.h Island.c Island.h Process.c Process.h start_line.c start_line.h
  group Control
    ../src/Control/: Control.c Control.h fuzzy.c fuzzy.h inertial_navigation.c inertial_navigation.h Link.c Link.h Meeting.c Meeting.h pid.c pid.h tools.c tools.h
  group Control/menu
    ../src/Control/menu/: menu.c menu.h
  group Drivers
    ../src/drivers/: ADC.c ADC.h common.c common.h DMA.c DMA.h Flash.c Flash.h Font.h FTM.c FTM.h GPIO.c GPIO.h GUI.h i2c.c i2c.h LCD.c LCD.h LED_BEEP.c LED_BEEP.h logo.h LPTMR.c LPTMR.h mpu9250.c mpu9250.h mykey.c mykey.h NRF24L01.c NRF24L01.h OV7725.c OV7725.h OV7725_REG.h pit.c pit.h SCCB.c SCCB.h SPI.c SPI.h TOF.c TOF.h UART.c UART.h
  group FatFS
    ../src/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c fsl_sdmmc_spec.h fsl_sdspi.c fsl_sdspi.h fsl_sdspi_disk.c fsl_sdspi_disk.h integer.h
  group FSL
    ../src/fsl/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_dma_manager.c fsl_dma_manager.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_pit.c fsl_pit.h fsl_port.h fsl_sim.c fsl_sim.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h MKV58F1M0xxx24_Project.c pin_mux.c pin_mux.h semihost_hardfault.c
  group System/CMSIS
    ../src/CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h fsl_device_registers.h MKV58F24.h MKV58F24_features.h mpu_armv7.h
  group System/Debug
    ../src/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h fsl_str.c fsl_str.h
  group System/Startup
    ../src/startup/: startup.c startup.h startup_MKV58F24.s system_MKV58F24.c system_MKV58F24.h
  group uGFX
    ../src/ugfx/drivers/gdisp/ILI9341/: board_ILI9341.h gdisp_lld_config.h gdisp_lld_ILI9341.c ILI9341.h
    ../src/ugfx/src/gdisp/: gdisp_driver.h
    ../src/ugfx/: gfx.h gfxconf.h
    ../src/ugfx/src/: gfx_mk.c
